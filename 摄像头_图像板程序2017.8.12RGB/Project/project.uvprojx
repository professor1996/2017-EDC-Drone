# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\Startup;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../User/src/: ILI9325_API.c main.c stm32f4xx_it.c delay.c led.c ILI9325.c OV7725.c Sccb.c Image.c PID.c Can1.c MyDataProcess.c Usart.c TIM3.c Show_Number.c TIM2.c stmflash.c
  group LIB
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_flash.c
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
  group STARTUP
    ../Libraries/Startup/: startup_stm32f4xx.s
  group CAUSAL
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
